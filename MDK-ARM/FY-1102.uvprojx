# Keil uVision project FY-1102.uvprojx, settings and files
target FY-1102 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FY-1102-NWK2 +hex
  AfterMake: fromelf.exe --bin  ..\MDK-ARM\FY-1102\FY-1102.axf --output ..\MDK-ARM\FY-1102/FY-1102.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER
  c misc: --C99
  c include: ..\Src;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Drivers/CMSIS/Include;..\Src\Driver;..\Src\Driver\LCD;..\Src\Component;..\Middlewares\Third_Party\FatFs\src;..\Middlewares\Third_Party\FatFs\src\drivers;..\Src\APP;..\Drivers\STM32_Cryptographic\Inc
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group STM32_Cryptographic
    ../Drivers/STM32_Cryptographic/Lib/: STM32CryptographicV3.0.0_CM4_KEIL_slsm1elfspf.lib
  group CMSIS
    ../Src/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f405xx.s
    ./: startup_stm32f407xx.s
  group HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_pwr.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_tim.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_spi.c stm32f4xx_hal_sd.c stm32f4xx_ll_sdmmc.c
  group FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c cc936.c
  group FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c croutine.c timers.c tasks.c event_groups.c list.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group DeviceType
    ../Src/: main.c stm32f4xx_it.c FreeRTOSConfig.h PubDef.c NWKmodbus.c modbus.c check.c
    ../Src/APP/: SysPara.c ClientApp.c UserPara.c DevPara.c
    ../Src/Component/: FY1000Pro.c FY188Pro.c FY2000Pro.c HZCRL_XPro.c XY188Pro.c HT2X188Pro.c BRC188Pro.c DDF2Pro.c
  group SRC
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c freertos.c TypeDef.c FRAM.c RTC.c bsp_driver_sd.c fatfs.c user_diskio.c kfifo.c rtx_cli.c ymodem.c calmd5.c common.c download.c UpdateParm.c SimilarLinux.c Serialization.c watchdog.c context.c Heartbeat.c debug.c
    ../Src/Driver/: LED.c SP706.c Beep.c M4_UART1.c M4_UART2.c M4_UART3.c M4_IIC1.c M4_CRC.c M4_IIC2.c PCF8563.c M4_SPI1.c W25QXX.c M4_SDIO.c Keyboard.c PowerRelay.c
    ../Src/Component/: Pulse.c CRC16.c IndepKEY.c AlarmClk.c UART_RBC.c
    ../Src/APP/: KeyboardAPP.c COM_Server.c APP_UI.c Sys_State.c FS_APP.c Calculate.c
    ../Src/Driver/LCD/: UC1698.c ZM.c
  group Doc
    ../Doc/: readme.txt
software components: CMSIS:CORE 5.2.0
